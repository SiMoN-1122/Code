# Keil uVision project BaseProject.uvprojx, settings and files
target GR5515_SK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: BaseProject +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK,DRIVER_TEST,APP_DRIVER_USE_ENABLE=0
  c include: ..\Inc;..\Src\config;..\..\components\boards;..\..\components\drivers_ext\gr551x;..\..\components\drivers_ext\st7735;..\..\components\drivers_ext\vs1005;..\..\components\libraries\app_alarm;..\..\components\libraries\app_assert;..\..\components\libraries\app_error;..\..\components\libraries\app_key;..\..\components\libraries\app_log;..\..\components\libraries\app_queue;..\..\components\libraries\app_timer;..\..\components\libraries\at_cmd;..\..\components\libraries\bsp;..\..\components\libraries\dfu_master;..\..\components\libraries\dfu_port;..\..\components\libraries\gui;..\..\components\libraries\gui\gui_config;..\..\components\libraries\hal_flash;..\..\components\libraries\hci_uart;..\..\components\libraries\pmu_calibration;..\..\components\libraries\ring_buffer;..\..\components\libraries\sensorsim;..\..\components\libraries\utility;..\..\components\patch\ind;..\..\components\sdk\;..\..\drivers\inc;..\..\external\freertos\include;..\..\external\segger_rtt;..\..\toolchain\cmsis\include;..\..\toolchain\gr551x\include;..\..\toolchain\gr551x\source\arm;..\APP\DataType;..\APP\LED;..\HW\Timer;..\HW\UART0;..\HW\ADC;..\APP\AD8233;..\APP\Ble;..\..\components\profiles\common;..\..\components\libraries\utility;..\..\components\profiles\gus;..\APP\JumperData;..\Alg\ECGAlg;..\Alg\PolynomialFit
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x30000000 size 0x40000
  scatter file: ..\..\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../toolchain/gr551x/source/: interrupt_gr55xx.c platform_gr55xx.c system_gr55xx.c
  group gr_stack_lib
    ../../components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_tim.c gr55xx_hal_gpio.c gr55xx_hal_aon_gpio.c gr55xx_hal_uart.c gr55xx_hal_adc.c
  group user_app
    ../Src/: gr55xx_hal_msp.c gr55xx_it.c
    ../Src/config/: custom_config.h
  group APP
    ../APP/LED/: LED.c
    ../APP/Main/: main.c
    ../HW/ADC/: gr551x_adc_voltage_api.c
    ../APP/AD8233/: AD8233.c
    ../APP/Ble/: user_app.c
    ../APP/JumperData/: JumperData.c
  group HW
    ../HW/Timer/: Timer.c
    ../HW/UART0/: Queue.c UART0.c
    ../HW/ADC/: ADC.c U16Queue.c
  group Alg
    ../Alg/ECGAlg/: ECGAlg.c ECGAnalyse.c FunTool.c
    ../Alg/PolynomialFit/: PolynomialFit.c
  group gr_profile
    ../../components/profiles/gus/: gus.c
    ../../components/profiles/common/: ble_prf_utils.c
  group callback
    ../Src/user_callback/: user_gap_callback.c user_gatt_common_callback.c
  group gr_libraries
    ../../components/libraries/app_error/: app_error.c
    ../../components/libraries/app_log/: app_log.c
    ../../components/libraries/utility/: utility.c
